# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\PWM;..\FreeRTOS\app;..\HARDWARE\KEY;..\HARDWARE\BSP_Init;..\HARDWARE\GPIO;..\HARDWARE\Timer_Encoder;..\CRC16;..\HARDWARE\WIFI;..\HARDWARE\Timer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c OS_AppObjCreate.c includes.h config.h data_init.c Car_config.h protocol.c PID.c
  group HARDWARE
    ../HARDWARE/BSP_Init/: Bsp_init.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/GPIO/: Motor_Dir_Output.c
    ../HARDWARE/Timer_Encoder/: timer_Encoder.c
    ../HARDWARE/WIFI/: wifi.c
    ../HARDWARE/Timer/: timer_read_encoder.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
    ../STM32F10x_FWLib/src/: stm32f10x_tim.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS_Task_App
    ../FreeRTOS/app/: Task_Encoder1.c Task_Motor1_Dir.c Task_Motor1_PWM.c Task_Motor1_PID.c Task_Motor2_Dir.c Task_Motor2_PWM.c Task_IdleTask.c Task_WIFI.c
  group README
    ../: README.TXT
  group CRC
    ../CRC16/: CRC16.c
